# Keil uVision project ANO_RTOS.uvprojx, settings and files
target ANO_RTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: .\TiDriver\inc;.\TiDriver\inc\driver_inc;.\TiDriver\inc\driver_hw;.\TiDriver\inc\driver_usb;.\TiDriver\inc\driver_usb\device;.\FreeRTOS;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\include;.\Main;.\McuDriver;.\SenserDriver;.\SenserDriver\icm20602;.\Extend;.\Extend\Ano;.\Extend\ring_buffer;.\Extend\mavlink\V2.0;.\Extend\mavlink\V2.0\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group TiDriver
    ./TiDriver/src/: startup_TM4C123.s usb_serial_structs.c
    ./TiDriver/: driverlib.lib usblib.lib
  group SenserDriver
    ./SenserDriver/: spi.c
    ./SenserDriver/icm20602/: icm20602.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group McuDriver
    ./McuDriver/: Drv_Bsp.c Drv_Led.c
  group Main
    ./Main/: main.c sysconfig.h
  group Mavlink
    ./Extend/mavlink/V2.0/: checksum.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_sha256.h mavlink_types.h protocol.h
    ./Extend/mavlink/V2.0/common/: mavlink.h common.h
  group Ano
    ./Extend/Ano/: Ano_Usb.c
  group RingBuf
    ./Extend/ring_buffer/: ring_buffer.c
